Commit message: updates

File: environments/assets/zone/zone.urdf (robot description, URDF)
Before this commit: robot zone.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.12 0.12 0.001; visual mesh filename=zone.obj scale=0.006 0.006 0.00005
